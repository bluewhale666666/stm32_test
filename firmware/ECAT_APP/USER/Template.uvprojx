# Keil uVision project Template.uvprojx, settings and files
target Template (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: "C:\Program Files\Keil_v5\ARM\ARMCC\bin\fromelf.exe"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\DI_KEY;..\HARDWARE\ETHERNET;..\HARDWARE\TIMER;..\HARDWARE\DO_LED;..\HARDWARE\SRAM;..\HARDWARE\ADC;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\HARDWARE\InterTemperate;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\USMART;..\LWIP;..\LWIP\app;..\LWIP\app\TCP_Client;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip_app\web_server_demo;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\MALLOC;..\HARDWARE\AD_DA_SPI;..\HARDWARE\SSC;..\HARDWARE\EXTI;..\HARDWARE\HW_ReadWrite;..\USER;..\HARDWARE\RS485;..\HARDWARE\Src;..\HARDWARE\CAN;..\HARDWARE\STMFLASH;..\HARDWARE\RS232;..\HARDWARE\INC;..\HARDWARE\power_inc;..\HARDWARE\TestMode
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/Src/: mailbox.c coeappl.c ecatappl.c ecatcoe.c ecatslv.c objdef.c sdoserv.c bootmode.c ecatfoe.c foeappl.c emcy.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/HW_ReadWrite/: hw_readwrite.c FoE_Application.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/AD_DA_SPI/: ad_da_spi.c
    ../HARDWARE/DO_LED/: do_led.c
    ../HARDWARE/DI_KEY/: di_key.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/CAN/: CAN.C
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/INC/: incappl.c
    ../HARDWARE/power_src/: ads1115a.c ads1115b.c ads1115c.c at24c16.c Boot_Initial.c ds18b20.c gpio.c ioin.c menu.c Recieve_Send_Command_Done.c usart.c
    ../HARDWARE/TestMode/: testmode.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_can.c stm32f4xx_flash.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
