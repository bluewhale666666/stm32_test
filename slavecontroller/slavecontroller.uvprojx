# Keil uVision project slavecontroller.uvprojx, settings and files
target SlaveController (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: slavecontroller
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\etherCAT;.\Power;.\CRC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407ZETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407ZETx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group etherCAT Slave Stack Code
    ./etherCAT/: 9252_HW.c bootmode.c coeappl.c ecatappl.c ecatcoe.c ecatfoe.c ecatslv.c emcy.c foeappl.c mailbox.c objdef.c Robot-Device.c sdoserv.c 9252_HW.h applInterface.h bootmode.h coeappl.h ecat_def.h ecatappl.h ecatcoe.h ecatfoe.h ecatslv.h emcy.h esc.h foeappl.h mailbox.h objdef.h Robot-Device.h Robot-DeviceObjects.h sdoserv.h
  group etherCAT Driver
    ./etherCAT/: PDIDriver.c SPIDriver.c SPIDriver.h PDIDriver.h
  group Power
    ./Power/: ADS1115Driver.c ADS1115Driver.h Command.c Command.h data_def.h PowerMenu.c PowerMenu.h KeyIn.h KeyIn.c TemperatureDriver.c TemperatureDriver.h
  group CRC
    ./CRC/: Crc16.c Crc16.h
software components: CMSIS:CORE 4.3.0, Device:STM32Cube HAL:CAN 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:STM32Cube HAL:TIM 1.7.13, Device:STM32Cube HAL:UART 1.7.13, Device:STM32Cube HAL:USART 1.7.13, Device:Startup 2.6.3
